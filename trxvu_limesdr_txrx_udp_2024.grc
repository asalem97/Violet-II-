options:
  parameters:
    author: Bradford MacEwen
    copyright: '2024'
    description: Sends data with FSK through Ettus SDR
    generate_options: qt_gui
    id: limesdr_bpsk_loopback
    output_language: python
    title: Ettus B205 Loopback FSK Test
  states: {}

blocks:
- name: bpsk_obj
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: fc_tx
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 145.90e6
    step: '100'
    stop: 145.92e6
    value: 145.91e6
  states: {state: disabled}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,2*samp_rate/sps,excess_bw,11*sps)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: rx_gain_default
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*sps
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: tx_gain_default_0
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-6'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*3500)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: intx
    value: '1200'
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {state: disabled}
- name: blocks_and_const_xx_0_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./rx_bits.hex
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1000'
    port: '27001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '27000'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk_obj
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '4'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    modulus: '2'
  states: {state: disabled}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '250'
    min: '16'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.0628'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: equ_gain
  id: parameter
  parameters:
    value: '0.01'
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    value: '0.35'
  states: {}
- name: fc_rx
  id: parameter
  parameters:
    type: eng_float
    value: 436.83e6
  states: {}
- name: fc_tx
  id: parameter
  parameters:
    type: eng_float
    value: 145.91e6
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1.0,samp_rate,7000,1000)
    type: fff
  states: {}
- name: hdlc_framer_with_preamble_0
  id: hdlc_framer_with_preamble
  parameters:
    num_postamble_bytes: '10'
    num_preamble_bytes: '10'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    rf_freq: fc_tx
    samp_rate: samp_rate
    serial: 1D7514D4CD338E
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: rx_gain
    gain_dB_ch1: rx_gain
    oversample: '0'
    rf_freq: fc_rx
    samp_rate: samp_rate
    serial: 1D7514D4CD338E
  states: {}
- name: loop_bw
  id: parameter
  parameters:
    value: '0.0628'
  states: {}
- name: nrzs_line_coding_0
  id: nrzs_line_coding
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc_tx
    fftsize: '1024'
    name: TX
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '22000'
    fc: fc_rx
    fftsize: '1024'
    name: RX
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: RX Bits
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: TX Wave
    size: '1024'
    srate: samp_rate
    tr_level: '0'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '10000'
    fc: fc_rx
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '192000'
    fc: fc_tx
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '140'
    samp_rate: samp_rate
    sym_rate: 2*samp_rate/sps
    type: fir_filter_fff
  states: {state: disabled}
- name: rx_gain_default
  id: parameter
  parameters:
    value: '56'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '320'
  states: {}
- name: tx_gain_default_0
  id: parameter
  parameters:
    value: '56'
  states: {}

connections:
- [analog_agc_xx_0, '0', fir_filter_xxx_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_1, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_and_const_xx_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_and_const_xx_0_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_not_xx_0_0, '0', blocks_and_const_xx_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_0, pdus, hdlc_framer_with_preamble_0, in]
- [blocks_throttle_0, '0', limesdr_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_not_xx_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_1, print]
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_1, print_pdu]
- [digital_hdlc_deframer_bp_0, out, blocks_socket_pdu_1, pdus]
- [digital_scrambler_bb_0, '0', digital_constellation_modulator_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [hdlc_framer_with_preamble_0, '0', nrzs_line_coding_0, '0']
- [limesdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [nrzs_line_coding_0, '0', blocks_pack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_1, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
