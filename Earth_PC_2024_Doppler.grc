options:
  parameters:
    generate_options: qt_gui
    id: trxvu_limesdr_txrx_udp
    output_language: python
    title: '"TRXVU LimeSDR Ground Software"'
  states: {}

blocks:
- name: dl_freq_ui
  id: variable_qtgui_entry
  parameters:
    type: real
    value: dl_freq
  states: {}
- name: rx_gain_ui
  id: variable_qtgui_range
  parameters:
    label: '"Recieve Gain (dB)"'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: rx_gain
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*sps
  states: {}
- name: squelch_ui
  id: variable_qtgui_range
  parameters:
    label: '"squelch"'
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '-30'
    value: '-50'
  states: {}
- name: tx_gain_ui
  id: variable_qtgui_range
  parameters:
    label: '"Transmit Gain (dB)"'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: tx_gain
  states: {}
- name: ul_freq_ui
  id: variable_qtgui_entry
  parameters:
    type: real
    value: ul_freq
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-6'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 192000/(2*math.pi*3500)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    type: intx
    value: '1200'
  states: {}
- name: blocks_and_const_xx_0_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_not_xx_0_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1000'
    port: '27001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '27000'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '0.0628318'
  states: {state: disabled}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '1000'
    rolloff: '0.35'
    samps_per_sym: '10'
    type: cc
    w: '0.01'
  states: {state: disabled}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '250'
    min: '16'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x00'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNUM_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: dl_freq
  id: parameter
  parameters:
    label: DL_Freq
    type: eng_float
    value: 145.91e6
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-4000'
    decim: '1'
    samp_rate: baud_rate*sps
    taps: firdes.complex_band_pass(1, baud_rate*sps, -baud_rate*sps/(200), baud_rate*sps/(200), 22000)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '5000'
    decim: '1'
    samp_rate: '192000'
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2), 22000)
    type: ccc
  states: {}
- name: hdlc_framer_with_preamble_0
  id: hdlc_framer_with_preamble
  parameters:
    num_postamble_bytes: '10'
    num_preamble_bytes: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: tx_gain_ui
    oversample: '0'
    rf_freq: ul_freq
    samp_rate: samp_rate
    serial: '0009083401881019'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: rx_gain
    gain_dB_ch1: rx_gain
    lna_path_ch0: '2'
    nco_freq_ch0: '1'
    oversample: '0'
    rf_freq: dl_freq
    samp_rate: baud_rate*sps
    serial: '0009083401881019'
  states: {}
- name: nrzs_line_coding_0
  id: nrzs_line_coding
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '10000'
    fc: ul_freq
    fftsize: '1024'
    name: '"Transmitted Uplink Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '10000'
    fc: dl_freq
    fftsize: '1024'
    name: RX FIN
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-60'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '50000'
    fc: dl_freq
    fftsize: '1024'
    name: RX source
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '10000'
    fc: ul_freq
    fftsize: '1024'
    int_max: '-20'
    int_min: '-110'
    name: '"TX Sink"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '10000'
    fc: dl_freq
    fftsize: '1024'
    name: '"RX Source"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '10000'
    fc: dl_freq
    fftsize: '1024'
    name: '"RX Out"'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.0035'
    decim: '1'
    gain: '1'
    ntaps: '160'
    samp_rate: sps*baud_rate
    sym_rate: 2*baud_rate
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: '70'
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_ccf
  states: {state: disabled}
- name: rx_gain
  id: parameter
  parameters:
    value: '56'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '160'
  states: {}
- name: trxv_uplink_fsk_modulator_0
  id: trxv_uplink_fsk_modulator
  parameters:
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    value: '56'
  states: {}
- name: ul_freq
  id: parameter
  parameters:
    label: UL_Freq
    type: eng_float
    value: '436830000'
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_1, '0']
- [analog_quadrature_demod_cf_0, '0', analog_agc_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_and_const_xx_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_and_const_xx_0_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_not_xx_0_0, '0', blocks_and_const_xx_0_0, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_0_0, pdus, hdlc_framer_with_preamble_0, in]
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_descrambler_bb_0, '0', blocks_not_xx_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_descrambler_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_1_0, '0']
- [digital_hdlc_deframer_bp_0, out, blocks_message_debug_1, print_pdu]
- [digital_hdlc_deframer_bp_0, out, blocks_socket_pdu_1, pdus]
- [digital_scrambler_bb_0, '0', trxv_uplink_fsk_modulator_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [hdlc_framer_with_preamble_0, '0', nrzs_line_coding_0, '0']
- [limesdr_source_0, '0', analog_simple_squelch_cc_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [limesdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [nrzs_line_coding_0, '0', digital_scrambler_bb_0, '0']
- [root_raised_cosine_filter_1, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_1_0, '0', digital_costas_loop_cc_0, '0']
- [trxv_uplink_fsk_modulator_0, '0', limesdr_sink_0, '0']
- [trxv_uplink_fsk_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [trxv_uplink_fsk_modulator_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
